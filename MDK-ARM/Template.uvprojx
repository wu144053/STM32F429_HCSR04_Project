# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,
  c include: .\..\;.\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\Libraries\CMSIS\Include;.\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Utilities\STM32F429I-Discovery;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STM32F429I-Discovery
    ./../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_ioe.c stm32f429i_discovery_l3gd20.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group STM32F4xx_StdPeriph_Driver
    ./../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_ltdc.c
  group User
    ./../: main.c stm32f4xx_it.c system_stm32f4xx.c
  group inc
    ../inc/: hcsr04.h pir.h key.h delay.h
  group src
    ../src/: delay.c hcsr04.c pir.c key.c uart.c
